## Kconfig
```kconfig
config ZMK_DRIVER_EXT_POWER_TRANSIENT
    bool "ext power transient"
    select ZMK_EXT_POWER
```
